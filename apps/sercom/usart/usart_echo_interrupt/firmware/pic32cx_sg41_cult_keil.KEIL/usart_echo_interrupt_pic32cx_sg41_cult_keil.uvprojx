# Keil uVision project usart_echo_interrupt_pic32cx_sg41_cult_keil.uvprojx, settings and files
target pic32cx_sg41_cult_keil (6140000::V6.14::ARMCLANG)
  device: PIC32CX1025SG41128 Microchip
  pack: Atmel.PIC32CX-SG41_DFP.1.1.134
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x20000000,0x8000) IRAM3(0x20000000,0x8000) IRAM4(0x47000000,0x2000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pic32cx_sg41_cult_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\pic32cx_sg41_cult_keil;..\src\packs\PIC32CX1025SG41128_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\src\config\pic32cx_sg41_cult_keil\pic32cx_sg41_cult_keil.sct
  group Harmony3
    ../src/config/pic32cx_sg41_cult_keil/peripheral/nvmctrl/: plib_nvmctrl.h plib_nvmctrl.c
    ../src/config/pic32cx_sg41_cult_keil/peripheral/sercom/usart/: plib_sercom2_usart.h plib_sercom_usart_common.h plib_sercom2_usart.c
    ../src/config/pic32cx_sg41_cult_keil/peripheral/evsys/: plib_evsys.h plib_evsys.c
    ../src/config/pic32cx_sg41_cult_keil/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h device_vectors.h initialization.c interrupts.c exceptions.c startup_keil.c
    ../src/packs/PIC32CX1025SG41128_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h fuses.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
    ../src/packs/PIC32CX1025SG41128_DFP/instance/: ac.h adc0.h adc1.h aes.h can0.h can1.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h fuses.h gclk.h gmac.h hmatrix.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h qspi.h ramecc.h rstc.h rtc.h sdhc0.h sdhc1.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sercom6.h sercom7.h supc.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h tcc3.h tcc4.h trng.h usb.h wdt.h
    ../src/packs/PIC32CX1025SG41128_DFP/: PIC32CX1025SG41128.h
    ../src/packs/PIC32CX1025SG41128_DFP/pio/: PIC32CX1025SG41128.h
    ../src/config/pic32cx_sg41_cult_keil/peripheral/port/: plib_port.h plib_port.c
    ../src/config/pic32cx_sg41_cult_keil/peripheral/clock/: plib_clock.h plib_clock.c
    ../src/config/pic32cx_sg41_cult_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/config/pic32cx_sg41_cult_keil/peripheral/cmcc/: plib_cmcc.h plib_cmcc.c
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm4.h mpu_armv7.h cachel1_armv7.h
    ../src/: main.c
    ../src/config/pic32cx_sg41_cult_keil/stdio/: keil_monitor.c
